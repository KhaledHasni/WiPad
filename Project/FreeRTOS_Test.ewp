# IAR project FreeRTOS_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51422_xxAC NordicSemi nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NRF51; NRF51422
  ICCARM.CCIncludePath2: Toolchain; ..\Kernel\FreeRTOS\source\include; ..\Kernel\FreeRTOS\portable\IAR\nrf51; ..\Kernel\FreeRTOS\portable\CMSIS\nrf51; ..\Configuration; ..\Board_Support\MCU; ..\Board_Support\MCU\hal; ..\Board_Support\MCU\clock; ..\Board_Support\MCU\common; ..\Middleware\Libraries\util; ..\Middleware\Libraries\log; ..\Middleware\Libraries\log\src; ..\Middleware\RF_Stack\Softdevice
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FreeRTOS_Test.bin
  ILINK.IlinkOutputFile: FreeRTOS_Test.out
  ILINK.IlinkIcfFile: FreeRTOS_Test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Board_Support/MCU/clock
    ../Board_Support/MCU/clock/: nrf_drv_clock.c
  group Board_Support/MCU/common
    ../Board_Support/MCU/common/: nrf_drv_common.c
  group Kernel/FreeRTOS
    ../Kernel/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Kernel/FreeRTOS/source/portable/MemMang/: heap_1.c
    ../Kernel/FreeRTOS/portable/IAR/nrf51/: port.c
    ../Kernel/FreeRTOS/portable/CMSIS/nrf51/: port_cmsis.c port_cmsis_systick.c
  group Middleware/Libraries/util
    ../Middleware/Libraries/util/: app_util_platform.c
  group Startup
    ../Startup/: iar_startup_nrf51.s main.c system_nrf51.c
