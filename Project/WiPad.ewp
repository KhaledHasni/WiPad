# IAR project WiPad.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52832_xxAA NordicSemi nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52832_XXAA
  ICCARM.CCIncludePath2: ..\Kernel\FreeRTOS\source\include; ..\Configuration; ..\Middleware\Libraries\util; Toolchain; ..\Board_Support\MCU; ..\Middleware\RF_Stack\Softdevice; ..\Kernel\FreeRTOS\portable\IAR\nrf52; ..\Kernel\FreeRTOS\portable\CMSIS\nrf52; ..\Board_Support\MCU\hal; ..\Board_Support\MCU\legacy; ..\Board_Support\MCU\clock; ..\Board_Support\MCU\power; ..\Middleware\Libraries\log; ..\Middleware\Libraries\experimental_section_vars; ..\Middleware\Libraries\strerror; ..\Middleware\Libraries\log\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WiPad.hex
  ILINK.IlinkOutputFile: WiPad.out
  ILINK.IlinkIcfFile: WiPad.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Board_Support/Drivers/MCU/clock
    ../Board_Support/MCU/clock/: nrf_drv_clock.c nrfx_clock.c
  group Kernel/FreeRTOS
    ../Kernel/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Kernel/FreeRTOS/source/portable/MemMang/: heap_1.c
    ../Kernel/FreeRTOS/portable/IAR/nrf52/: port.c
    ../Kernel/FreeRTOS/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Middleware/Libraries/util
    ../Middleware/Libraries/util/: app_util_platform.c
  group Startup
    ../Startup/: iar_startup_nrf52.s main.c system_nrf52.c
